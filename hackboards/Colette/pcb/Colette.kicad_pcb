# Repository transdryad/hackpad

## KiCad design hackboards/Colette/pcb/Colette.kicad_pcb

File hackboards/Colette/README.md:

# Colette
A keyboard designed to be ergonomic, clean, convenient, maintainable, and versatile.
It is optimized for English, but can type every character supported by the US International layout (though it's not followed.)
By default, it uses Colemak Mod-DH with a few changes to punctuation.

# Software used:
Kicad, Pycharm, FreeCAD, QMK, and Keyboard-Layout-Editor.com

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1, J2: AudioJack3; Jack_3.5mm_CUI_SJ1-3523N_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28: SW_Push; SW_Cherry_MX_1.00u_PCB
SW29: SW_Push; SW_Cherry_MX_2.00u_PCB
SW-1, SW-2, SW-3, SW-4, SW-5, SW-6, SW-7, SW-8, SW-9, SW-10, SW-11, SW-12, SW-13, SW-14, SW-15, SW-16, SW-17, SW-18, SW-19, SW-20, SW-21, SW-22, SW-23, SW-24, SW-26, SW-27, SW-28, SW-29: SW_Push; SW_Cherry_MX_1.00u_PCB
SW-25: SW_Push; SW_Cherry_MX_2.00u_PCB
U1, U2: Pico; RaspberryPi_Pico_Common_THT

Connections:
COL1: SW1.2, SW7.2, SW13.2, SW19.2, SW25.2, U1.2 (GPIO1)
COL2: SW2.2, SW8.2, SW14.2, SW20.2, SW26.2, U1.4 (GPIO2)
COL3: SW3.2, SW9.2, SW15.2, SW21.2, SW27.2, U1.5 (GPIO3)
COL4: SW4.2, SW10.2, SW16.2, SW22.2, SW28.2, U1.6 (GPIO4)
COL5: SW5.2, SW11.2, SW17.2, SW23.2, SW29.2, U1.7 (GPIO5)
COL6: SW6.2, SW12.2, SW18.2, SW24.2, U1.9 (GPIO6)
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: D18.2 (A), SW18.1
unnamed: D19.2 (A), SW19.1
unnamed: D20.2 (A), SW20.1
unnamed: D21.2 (A), SW21.1
unnamed: D22.2 (A), SW22.1
unnamed: D23.2 (A), SW23.1
unnamed: D24.2 (A), SW24.1
unnamed: D25.2 (A), SW25.1
unnamed: D26.2 (A), SW26.1
unnamed: D27.2 (A), SW27.1
unnamed: D28.2 (A), SW28.1
unnamed: D29.2 (A), SW29.1
unnamed: D30.2 (A), SW-1.1
unnamed: D31.2 (A), SW-7.1
unnamed: D32.2 (A), SW-13.1
unnamed: D33.2 (A), SW-19.1
unnamed: D34.2 (A), SW-25.1
unnamed: D35.2 (A), SW-2.1
unnamed: D36.2 (A), SW-8.1
unnamed: D37.2 (A), SW-14.1
unnamed: D38.2 (A), SW-20.1
unnamed: D39.2 (A), SW-26.1
unnamed: D40.2 (A), SW-3.1
unnamed: D41.2 (A), SW-9.1
unnamed: D42.2 (A), SW-15.1
unnamed: D43.2 (A), SW-21.1
unnamed: D44.2 (A), SW-27.1
unnamed: D45.2 (A), SW-4.1
unnamed: D46.2 (A), SW-10.1
unnamed: D47.2 (A), SW-16.1
unnamed: D48.2 (A), SW-22.1
unnamed: D49.2 (A), SW-28.1
unnamed: D50.2 (A), SW-5.1
unnamed: D51.2 (A), SW-11.1
unnamed: D52.2 (A), SW-17.1
unnamed: D53.2 (A), SW-23.1
unnamed: D54.2 (A), SW-29.1
unnamed: D55.2 (A), SW-6.1
unnamed: D56.2 (A), SW-12.1
unnamed: D57.2 (A), SW-18.1
unnamed: D58.2 (A), SW-24.1
unnamed: J1.S, U1.38 (GND)
unnamed: J2.S, U2.38 (GND)
unnamed: J1.T, U1.1 (GPIO0)
unnamed: J1.R, U1.39 (VSYS)
unnamed: J2.T, U2.1 (GPIO0)
unnamed: J2.R, U2.39 (VSYS)
RCOL1: SW-1.2, SW-7.2, SW-13.2, SW-19.2, U2.2 (GPIO1)
RCOL2: SW-2.2, SW-8.2, SW-14.2, SW-20.2, SW-25.2, U2.4 (GPIO2)
RCOL3: SW-3.2, SW-9.2, SW-15.2, SW-21.2, SW-26.2, U2.5 (GPIO3)
RCOL4: SW-4.2, SW-10.2, SW-16.2, SW-22.2, SW-27.2, U2.6 (GPIO4)
RCOL5: SW-5.2, SW-11.2, SW-17.2, SW-23.2, SW-28.2, U2.7 (GPIO5)
RCOL6: SW-6.2, SW-12.2, SW-18.2, SW-24.2, SW-29.2, U2.9 (GPIO6)
ROW1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.10 (GPIO7)
ROW2: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.11 (GPIO8)
ROW3: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.12 (GPIO9)
ROW4: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.13 (GND)
ROW5: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), U1.14 (GPIO10)
RROW1: D30.1 (K), D35.1 (K), D40.1 (K), D45.1 (K), D50.1 (K), D55.1 (K), U2.10 (GPIO7)
RROW2: D31.1 (K), D36.1 (K), D41.1 (K), D46.1 (K), D51.1 (K), D56.1 (K), U2.11 (GPIO8)
RROW3: D32.1 (K), D37.1 (K), D42.1 (K), D47.1 (K), D52.1 (K), D57.1 (K), U2.12 (GPIO9)
RROW4: D33.1 (K), D38.1 (K), D43.1 (K), D48.1 (K), D53.1 (K), D58.1 (K), U2.13 (GND)
RROW5: D34.1 (K), D39.1 (K), D44.1 (K), D49.1 (K), D54.1 (K), U2.14 (GPIO10)

Board: 2 copper layers, 412.8 x 256.2 mm, 120 parts (0 on the bottom side), 86 nets.

## Commit log

2025-03-15 Transfer
